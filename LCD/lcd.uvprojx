# Keil uVision project lcd.uvprojx, settings and files
target lcd (ARM-ADS)
  device: STM32F031C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lcd
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\board;.\src;.\stm32fxx\STM32F0xx_StdPeriph_Driver\inc;.\stm32fxx\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group startup
    ./stm32fxx/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ./stm32fxx/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group lib
    ./stm32fxx/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group board
    ./board/: wolf_delay.c wolf_led.c font.c wolf_key.c wolf_LCD9341.c
  group src
    ./src/: main.c stm32f0xx_it.c
